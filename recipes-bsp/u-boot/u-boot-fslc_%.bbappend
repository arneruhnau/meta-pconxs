SRCBRANCH="pconxs-2014.07-u100"
SRCREV = "AUTOINC"
SRC_URI = "git://github.com/arneruhnau/u-boot-pconxs.git;protocol=http;branch=${SRCBRANCH}"
