SRCBRANCH = "can-gpio-keys"
SRCREV = "AUTOINC"

require linux-stable.inc
